PRINC = "1"

# Build OpenGL/ES support if available

QT_GLFLAGS_colibri-t20 = "-opengl es2 "
QT_GLFLAGS_colibri-t30 = "-opengl es2 "
QT_GLFLAGS_apalis-t30 = "-opengl es2 "
