LICENSE = "prop"
#dummy to live with a bbappend in meta-oe
COMPATIBLE_MACHINE = "none"